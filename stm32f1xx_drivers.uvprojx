# Keil uVision project stm32f1xx_drivers.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1xx_drivers
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=5 wLevel=3
  c include: drivers\inc\;bsp\
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: 001led_toggle.c 002led_button.c 003button_interupt.c 004spi_tx_testing.c 005spi_txonly_arduino.c 006spi_cmd_handing.c 008i2c_master_tx_testing.c 100rtc_lcd.c
  group Drivers_Inc
    ./drivers/inc/: stm32f103xx.h stm32f103xx_gpio_driver.h stm32f103xx_spi_driver.h stm32f103xx_i2c_driver.h stm32f103xx_usart_driver.h stm32f103xx_rcc_driver.h
  group Drivers_Src
    ./drivers/src/: stm32f103xx_gpio_driver.c stm32f103xx_spi_driver.c stm32f103xx_i2c_driver.c stm32f103xx_usart_driver.c stm32f103xx_rcc_driver.c
  group BSP
    ./bsp/: ds1307.h ds1307.c lcd.h lcd.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
